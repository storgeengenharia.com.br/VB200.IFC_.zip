Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VB200.IFC
Time: 2024-10-09T18:00:35
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Canto TDC (8)
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Chapa Duto
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Duto Bocal
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa do Meio
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Cone de Aspiração 250
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Perfil TDC VB200 (4)
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Perfil TDC VB200m (4)
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Suporte Motor
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Tampa Motor
In: Default Storey
Material: Steel
